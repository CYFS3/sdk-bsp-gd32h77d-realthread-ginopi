# Keil uVision project project.uvprojx, settings and files
target Gino_driver_usb_host (6240000::V6.24::ARMCLANG)
  device: GD32H77DIW GigaDevice
  pack: GigaDevice.GD32H77x_78x_DFP.0.6.1
  cpu: IRAM(0x24000000,0x000C0000) IRAM2(0x00000000,0x00020000) IROM(0x08010000,0x001F0000) IROM2(0x08200000,0x0780000) XRAM(0x20000000,0x00040000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND, GD32H77DXW, __RTTHREAD__, __STDC_LIMIT_MACROS, USE_STDPERIPH_DRIVER, RT_USING_LIBC
  c include: rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\eventfd;libraries\gd32-arm-cmsis-latest\GD32H77x_78x;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\poll;rt-thread\components\dfs\dfs_v1\filesystems\elmfat;rt-thread\components\legacy\usb\usbhost\include;rt-thread\components\dfs\dfs_v1\include;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\extension;rt-thread\components\dfs\dfs_v1\filesystems\romfs;rt-thread\components\net\utest;libraries\gd32_drivers\config;libraries\Board_Drivers;rt-thread\components\legacy\usb\usbhost;rt-thread\components\libc\posix\io\epoll;rt-thread\components\libc\compilers\common\include;rt-thread\libcpu\arm\common;rt-thread\components\finsh;rt-thread\components\drivers\phy;libraries\gd32_drivers;libraries\gd32_drivers\usb;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\drivers\include;rt-thread\components\libc\posix\ipc;rt-thread\include;libraries\gd32-arm-cmsis-latest\GD32H77x_78x\GD\GD32H77x_78x\Include;libraries\gd32-arm-series-latest\GD32H77x_78x\GD32H77x_78x_standard_peripheral\Include;applications;rt-thread\components\legacy\usb\usbhost\class;rt-thread\components\legacy\usb\usbhost\core;rt-thread\components\drivers\smp_call;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\legacy\include;rt-thread\components\dfs\dfs_v1\filesystems\devfs;.
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x1f0000
  memory RVCT5: ROM 0x8200000 size 0x780000
  memory RVCT6: RAM 0x20000000 size 0x40000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xc0000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: device_probe.c main.c
  group Board_Drivers
    libraries/Board_Drivers/: board.c drv_filesystem.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: dev_pin.c
    rt-thread/components/drivers/serial/: dev_serial.c
  group Drivers
    libraries/gd32_drivers/: drv_gpio.c drv_usart.c
    libraries/gd32_drivers/usb/: drv_usb_core.c gd32h7_usb_hw.c drv_otghs_host.c drv_usb_host.c drv_usbh_int.c drv_usbh_pipe.c drv_usbh_trans.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/dfs_v1/filesystems/romfs/: dfs_romfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    rt-thread/src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    libraries/gd32-arm-cmsis-latest/GD32H77x_78x/GD/GD32H77x_78x/Source/ARM/: startup_gd32h77x_78x.s
    libraries/gd32-arm-cmsis-latest/GD32H77x_78x/GD/GD32H77x_78x/Source/: system_gd32h77x_78x.c
    libraries/gd32-arm-series-latest/GD32H77x_78x/GD32H77x_78x_standard_peripheral/Source/: gd32h77x_78x_dma.c gd32h77x_78x_exti.c gd32h77x_78x_gpio.c gd32h77x_78x_misc.c gd32h77x_78x_pmu.c gd32h77x_78x_rcu.c gd32h77x_78x_syscfg.c gd32h77x_78x_usart.c
  group rt_usbh
    rt-thread/components/legacy/usb/usbhost/core/: usbhost_core.c driver.c usbhost.c hub.c
    rt-thread/components/legacy/usb/usbhost/class/: mass.c udisk.c
