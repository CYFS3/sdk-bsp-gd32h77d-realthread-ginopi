# Keil uVision project project.uvprojx, settings and files
target Gino_driver_rtc (6240000::V6.24::ARMCLANG)
  device: GD32H77DIW GigaDevice
  pack: GigaDevice.GD32H77x_78x_DFP.0.6.1
  cpu: IRAM(0x24000000,0x000C0000) IRAM2(0x00000000,0x00020000) IROM(0x08010000,0x001F0000) IROM2(0x08200000,0x0780000) XRAM(0x20000000,0x00040000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__, USE_STDPERIPH_DRIVER, GD32H77DXW, RT_USING_ARMLIBC, RT_USING_LIBC
  c include: applications;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\drivers\include;rt-thread\include;rt-thread\components\drivers\include;libraries\Board_Drivers;rt-thread\components\drivers\include;rt-thread\components\net\utest;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\libc\posix\io\epoll;rt-thread\components\libc\posix\io\poll;rt-thread\components\drivers\include;libraries\gd32_drivers;libraries\gd32-arm-cmsis-latest\GD32H77x_78x;rt-thread\components\drivers\phy;libraries\gd32_drivers\config;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\libc\compilers\common\extension;.;rt-thread\libcpu\arm\common;rt-thread\components\libc\compilers\common\extension\fcntl\octal;libraries\gd32-arm-cmsis-latest\GD32H77x_78x\GD\GD32H77x_78x\Include;rt-thread\components\drivers\smp_call;rt-thread\components\libc\posix\ipc;libraries\gd32-arm-series-latest\GD32H77x_78x\GD32H77x_78x_standard_peripheral\Include;rt-thread\components\drivers\include;libraries\gd32_drivers\usb;rt-thread\components\libc\compilers\common\include;rt-thread\components\drivers\include;rt-thread\components\utilities\ulog
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x1f0000
  memory RVCT5: ROM 0x8200000 size 0x780000
  memory RVCT6: RAM 0x20000000 size 0x40000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xc0000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: device_probe.c main.c rtc_alarm_example.c
  group Board_Drivers
    libraries/Board_Drivers/: board.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: dev_pin.c
    rt-thread/components/drivers/rtc/: dev_alarm.c dev_rtc.c
    rt-thread/components/drivers/serial/: dev_serial.c
  group Drivers
    libraries/gd32_drivers/: drv_gpio.c drv_usart.c drv_rtc.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    rt-thread/src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    libraries/gd32-arm-cmsis-latest/GD32H77x_78x/GD/GD32H77x_78x/Source/ARM/: startup_gd32h77x_78x.s
    libraries/gd32-arm-cmsis-latest/GD32H77x_78x/GD/GD32H77x_78x/Source/: system_gd32h77x_78x.c
    libraries/gd32-arm-series-latest/GD32H77x_78x/GD32H77x_78x_standard_peripheral/Source/: gd32h77x_78x_dma.c gd32h77x_78x_exti.c gd32h77x_78x_gpio.c gd32h77x_78x_misc.c gd32h77x_78x_pmu.c gd32h77x_78x_rcu.c gd32h77x_78x_rtc.c gd32h77x_78x_syscfg.c gd32h77x_78x_usart.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
